# GNURadio toolchain
TOOLCHAIN_HOST_TASK = "task-e100-toolchain-host"
TOOLCHAIN_TARGET_TASK = "task-e100-toolchain-target"

require recipes/meta/meta-toolchain.bb
SDK_SUFFIX = "toolchain-e100"

